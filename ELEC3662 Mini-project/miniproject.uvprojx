# Keil uVision project miniproject.uvprojx, settings and files
target TM4C123GH6PM (6240000::V6.24::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: miniproject
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group src
    ./: main.c calculator.c keypad.c lcd.c system.c splash.c games.c
  group config
    ./: pin_definitions.h
  group docs
    ./: README.txt EasterEggs.txt
  group inc
    ./: calculator.h lcd.h keypad.h system.h splash.h games.h
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
